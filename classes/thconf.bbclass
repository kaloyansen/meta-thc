# thconf.bbclass

thconf_loop() {
    echo fuck you
}

EXPORT_FUNCTIONS loop

